# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F072CxB Puya
  pack: Puya.PY32F0xx_DFP.1.2.2
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F072CxB
  c include: ..\Inc;..\Drivers\BSP\PY32F072Cxx_Start_Kit;..\Drivers\CMSIS\Device\PY32F072C\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\PY32F072C\Include;..\Drivers\PY32F072C_HAL_Driver\Inc;..\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Common
    ./: startup_py32f072cxx.s
    ../Src/: system_py32f072c.c
  group Application/User
    ../Src/: main.c py32f072c_hal_msp.c py32f072c_it.c
  group BSP/py32f072cxx_Start_Kit
    ../Drivers/BSP/PY32F072Cxx_Start_Kit/: py32f072cxx_Start_Kit.c
  group Drivers/PY32F072C_HAL_Driver
    ../Drivers/PY32F072C_HAL_Driver/Src/: py32f072c_hal.c py32f072c_hal_cortex.c py32f072c_hal_gpio.c py32f072c_hal_pwr.c py32f072c_hal_rcc.c py32f072c_hal_rcc_ex.c py32f072c_hal_uart.c py32f072c_hal_dma.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.2.0
